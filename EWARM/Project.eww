<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\f746g_i2c.ewp</path>
  </project>
  <batchBuild />
</workspace>
